# Keil uVision project XDrive_APP.uvprojx, settings and files
target XDrive_APP (6110000::V6.11::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XDrive_APP +hex
  AfterMake: fromelf --bin ".\XDrive_APP\XDrive_APP.axf" --output ".\BIN\xdrive_app.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Base_Drivers;..\Base_Math;..\Config;..\Control;..\Data_Link;..\Debug;..\Kernel;..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c adc.c dma.c gpio.c spi.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c can.c usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Base_Drivers
    ../Base_Drivers/: kernel_port.c mt6816.c hw_elec.c uart_mixed.c signal_port.c modbus_slave.c
  group Base_Math
    ../Base_Math/: rein_math.c sin_form.c
  group Config
    ../Config/: stockpile_f103cb.c
  group Control
    ../Control/: control_config.c motor_control.c encode_cali.c Location_Tracker.c Speed_Tracker.c Current_Tracker.c Move_Reconstruct.c Location_Interp.c power_detect.c
  group Debug
    ../Debug/: button.c
  group Kernel
    ../Kernel/: loop.c loop_it.c
